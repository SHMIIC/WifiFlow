# Keil uVision project Wifi_Flow.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Wifi_Flow +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\src
  group src
    ./src/: main.c rey_config.c config.h rey_config.h
  group lib
    ./lib/: delay.c LCD1602B.c USART.C timer.c command.c
    ./: Soft_Uart.c
